## boards/shields/xzp_nrf52840/Kconfig.defconfig
```kconfig
if SHIELD_XZP_NRF52840

config ZMK_KEYBOARD_NAME
    default "xzp"

endif # SHIELD_XZP_NRF52840
```
